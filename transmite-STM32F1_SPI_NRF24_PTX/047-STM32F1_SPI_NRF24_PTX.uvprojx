# Keil uVision project 047-STM32F1_SPI_NRF24_PTX.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 047-STM32F1_SPI_NRF24_PTX
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c nrf24_drive.c SPI_drive.c systick_time.c uart_drive.c gp_drive.h nrf24_drive.h SPI_drive.h systick_time.h uart_drive.h gp_drive.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
